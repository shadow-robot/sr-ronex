Commit message: Test the simple controller with analog input.

File: sr_ronex_examples/model/simple_robot.urdf (robot description, URDF)
Before this commit: robot simple_robot, 2 links, 1 joints
Links:
- removed link head
- link base_link: geometry 
Joints:
- removed joint head_swivel
